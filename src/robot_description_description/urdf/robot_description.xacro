Commit message: Updated

File: src/robot_description_description/urdf/robot_description.xacro (robot description, xacro)
@@ -99,5 +99,5 @@
   <parent link="base_link"/>
   <child link="right_wheel_1"/>
-  <axis xyz="0.0 -1.0 0.0"/>
+  <axis xyz="0.0 1.0 0.0"/>
 </joint>
 </robot>
